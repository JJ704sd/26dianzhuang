# Keil uVision project Demo15_Multi_Function_Monitor.uvprojx, settings and files
target GD32E230C8T6 (6210000::V6.21::ARMCLANG)
  device: GD32E230C8 GigaDevice
  pack: GigaDevice.GD32E23x_DFP.1.1.0
  cpu: IRAM(0x20000000,0x0002000) IROM(0x08000000,0x0010000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: Demo15_Multi_Function_Monitor +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: GD32E230
  c misc: -Wno-invalid-source-encoding -Oz
  c include: ..\User;..\Firmware\CMSIS;..\Firmware\CMSIS\GD\GD32E23x\Include;..\Firmware\GD32E23x_standard_peripheral\Include;..\Hardware;..\Middle;..\APP
  asm define: GD32E230
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User
    ../User/: gd32e23x_it.c main.c systick.c
  group Firmware
    ../Firmware/GD32E23x_standard_peripheral/Source/: gd32e23x_adc.c gd32e23x_cmp.c gd32e23x_crc.c gd32e23x_dbg.c gd32e23x_dma.c gd32e23x_exti.c gd32e23x_fmc.c gd32e23x_fwdgt.c gd32e23x_gpio.c gd32e23x_i2c.c gd32e23x_misc.c gd32e23x_pmu.c gd32e23x_rcu.c gd32e23x_rtc.c gd32e23x_spi.c gd32e23x_syscfg.c gd32e23x_timer.c gd32e23x_usart.c gd32e23x_wwdgt.c
  group CMSIS
    ../Firmware/CMSIS/GD/GD32E23x/Source/ARM/: startup_gd32e23x.s
    ../Firmware/CMSIS/GD/GD32E23x/Source/: system_gd32e23x.c
  group Doc
    ../Doc/: readme.md
  group Hardware
    ../Hardware/: hw_led.c hw_gpio.c hw_key.c hw_ec11.c hw_lcdinit.c hw_spi.c hw_tim.c hw_adc.c
  group Middle
    ../Middle/: mid_timer.c mid_pwm.c mid_lcd.c mid_adc.c scope_view.c scope_metrics.c ecg_acq_core.c
  group APP
    ../APP/: osc_task.c hess_analyzer.c hess_splash.c
software components: CMSIS:CORE 5.6.0
